# Keil uVision project NVIC_TEST.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NVIC_TEST
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: NVIC_program.c RCC_program.c SCB_program.c BIT_MATH.h NVIC_config.h NVIC_interface.h NVIC_private.h RCC_config.h RCC_interface.h RCC_private.h SCB_config.h SCB_interface.h SCB_private.h STD_TYPES.h main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
